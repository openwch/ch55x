# Keil uVision project ch559_P4_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x58RD SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x7FFF) CLOCK(40000000)
  output: P4_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User
  group user
    ./User/: P4_1.C
