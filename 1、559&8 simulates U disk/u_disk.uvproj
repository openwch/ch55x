# Keil uVision project u_disk.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: u_disk +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: SPI0Flash.C
