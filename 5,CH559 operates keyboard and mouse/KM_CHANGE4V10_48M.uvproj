# Keil uVision project KM_CHANGE4V10_48M.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: KM_CHANGE4V10 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: MAIN.C KM_CHANGE4V10_48M.LIB
